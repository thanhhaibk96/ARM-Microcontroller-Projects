# Keil uVision project AUV_Black_Box.uvprojx, settings and files
target AUV_Black_Box (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AUV_Black_Box +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE = 8000000
  c include: ..\AUV_Black_Box;.\CMSIS;.\Startup;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c User_CAN.c User_ResetHardfault.c User_GSM.c User_Delay.c User_XBEE.c User_GPS_INS.c User_RCServo.c
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_iwdg.c
