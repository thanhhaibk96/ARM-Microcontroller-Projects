# Keil uVision project Board_STM32F4_1.uvprojx, settings and files
target Board_STM32F407_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Board_STM32F4_1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\AUV_Board_STM32F4_1_v3_edited_for_project;.\STM32F4xx_StdPeriph_Driver\inc;.\CMSIS;.\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c my_delay.c my_camera.c my_can.c my_altimeter.c my_io.c my_bms24v10ah.c my_bms24v40ah.c my_hardwarereset.c my_straingauge.c my_pistonmotor.c
  group CMSIS
    ./CMSIS/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_wwdg.c stm32f4xx_spi.c stm32f4xx_adc.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2
